# Keil uVision project mcu.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: mcu +hex
  AfterMake: .\tools\user.bat
  c flags: Optimize=8 SizeSpeed=1
  c include: .\INC
  asm include: .\INC
  group application
    ./SRC/: STARTUP.A51 main.c interrupt.c initial.c ISD51.A51
