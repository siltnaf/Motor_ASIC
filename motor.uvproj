# Keil uVision project motor.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: motor +hex
  AfterMake: .\tools\user.bat
  c flags: SizeSpeed=1
  c include: .\INC
  asm include: .\INC
  group application
    ./SRC/: STARTUP.A51 main.c initial.c interrupt.c lib.c ISD51.A51
